PACKAGECONFIG_append = " networkd resolved"
RDEPENDS_${PN}_append = " wpa-supplicant "

